.SUBCKT headerB vcc VIN vssx
Mqn1 net4 VIN VIN vssx nulvt L=0.04u W=0.72u
Mqp1 net4 VIN vcc vcc pulvt L=0.04u W=0.72u
.ENDS
