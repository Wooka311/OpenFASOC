.subckt SLC VIN VINB VOUT vssx vcc
Mqp0 net02 net07 vcc vcc php L=0.04u W=0.09u
Mqp1 net03 net03 net02 vcc pulvt L=0.04u W=0.09u
Mqp3 net06 net03 vcc vcc php L=0.04u W=0.09u
Mqp4 net07 net07 net06 vcc pulvt L=0.04u W=0.09u
Mqp6 VOUT net06 vcc vcc php L=0.04u W=0.135u
Mqn4 VOUT net07 vssx vssx nhp L=0.04u W=0.18u
Mqn0 net03 VINB vssx vssx nulvt L=0.04u W=0.135u
Mqn8 net07 VIN vssx vssx nulvt L=0.04u W=0.135u
.ends
